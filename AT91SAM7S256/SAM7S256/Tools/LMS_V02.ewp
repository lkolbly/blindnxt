# IAR project LMS_V02.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: ..\Lib\dl4tptinl8n.h
  General.OGChipSelectEditMenu: AT91SAM7S256 Atmel AT91SAM7S256
  ICCARM.CCDefines: PROTOTYPE_PCB_4; NEW_MENU
  ICCARM.CCIncludePath2: ..\..\; ..\Include\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: at91SAM7S256_Remap.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Binary Output (ARM, debug)
  as the first configuration, except:
  group (top)
    ../../Source/: c_button.c c_cmd.c c_comm.c c_display.c c_input.c c_ioctrl.c c_loader.c c_lowspeed.c c_output.c c_sound.c c_ui.c d_bt.c d_button.c d_display.c d_hispeed.c d_input.c d_ioctrl.c d_loader.c d_lowspeed.c d_output.c d_sound.c d_timer.c d_usb.c m_sched.c
    ../Include/: Cstartup.s79 Cstartup_SAM7.c
